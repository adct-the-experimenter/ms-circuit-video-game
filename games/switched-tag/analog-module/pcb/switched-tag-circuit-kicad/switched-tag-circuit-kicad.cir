.title KiCad schematic
.include "/home/pab/niche-engineer-proj/analog-circuit-game-console/ms-circuit-video-games/spice-models/1N914.lib"
.include "/home/pab/niche-engineer-proj/analog-circuit-game-console/ms-circuit-video-games/spice-models/Lm358.lib"
.include "/home/pab/niche-engineer-proj/analog-circuit-game-console/ms-circuit-video-games/spice-models/rul035n02.lib"
.save all
.probe alli
V6 /p1y GND DC 1
V1 /p1x GND DC 1.5 SIN( 1.5 1.5 10 )
V8 /p2y GND DC 1
V7 /p2x GND DC 1
V2 /p1_it_button GND PULSE( 0 3 2 0.1 0.1 1 2 )
V3 /p2_it_button GND PULSE( 0 3 1 0.1 0.1 1 2 )
V5 +3V3 GND DC 3.3
V4 -3V3 GND DC -3.3
R4 /p2y Net-_U2--_ 10k
R8 Net-_U2--_ /Switched_Tag_2D_Collision_Detection/ydiff 10k
XU2 Net-_U2-+_ Net-_U2--_ +3V3 -3V3 /Switched_Tag_2D_Collision_Detection/ydiff LM358/NS
R2 /p2x Net-_U1--_ 10k
R5 GND Net-_U1-+_ 10k
R1 /p1x Net-_U1-+_ 10k
R7 Net-_U1--_ /Switched_Tag_2D_Collision_Detection/xdiff 10k
R3 /p1y Net-_U2-+_ 10k
R6 GND Net-_U2-+_ 10k
XU1 Net-_U1-+_ Net-_U1--_ +3V3 -3V3 /Switched_Tag_2D_Collision_Detection/xdiff LM358/NS
R9 /Switched_Tag_2D_Collision_Detection/xdiff Net-_D1-K_ 10k
R15 Net-_D1-A_ Net-_D3-A_ 5k
D3 Net-_D3-A_ Net-_D1-A_ D1N914
R11 Net-_D1-K_ Net-_D3-A_ 10k
R12 /Switched_Tag_2D_Collision_Detection/xdiff Net-_D1-A_ 10k
D1 Net-_D1-A_ Net-_D1-K_ D1N914
XU3 GND Net-_D1-K_ +3V3 -3V3 Net-_D1-A_ LM358/NS
R10 /Switched_Tag_2D_Collision_Detection/ydiff Net-_D2-K_ 10k
R16 Net-_D2-A_ Net-_D4-A_ 5k
D4 Net-_D4-A_ Net-_D2-A_ D1N914
D2 Net-_D2-A_ Net-_D2-K_ D1N914
R13 Net-_D2-K_ Net-_D4-A_ 10k
R14 /Switched_Tag_2D_Collision_Detection/ydiff Net-_D2-A_ 10k
XU4 GND Net-_D2-K_ +3V3 -3V3 Net-_D2-A_ LM358/NS
R21 Net-_U7--_ GND 5k
R22 Net-_U7--_ /Switched_Tag_2D_Collision_Detection/diff_sum_result 10k
XU7 Net-_U7-+_ Net-_U7--_ +3V3 -3V3 /Switched_Tag_2D_Collision_Detection/diff_sum_result LM358/NS
R19 /Switched_Tag_2D_Collision_Detection/abs_xdiff Net-_U7-+_ 10k
XU5 GND Net-_D1-A_ +3V3 -3V3 /Switched_Tag_2D_Collision_Detection/abs_xdiff LM358/NS
R17 Net-_D1-A_ /Switched_Tag_2D_Collision_Detection/abs_xdiff 10k
R20 /Switched_Tag_2D_Collision_Detection/abs_ydiff Net-_U7-+_ 10k
R18 Net-_D2-A_ /Switched_Tag_2D_Collision_Detection/abs_ydiff 10k
XU6 GND Net-_D2-A_ +3V3 -3V3 /Switched_Tag_2D_Collision_Detection/abs_ydiff LM358/NS
D5 Net-_D5-A_ /collision_detect_signal D1N914
R24 GND Net-_U8-+_ 100k
R23 Net-_U8-+_ +3V3 100k
R25 GND /collision_detect_signal 10k
XU8 Net-_U8-+_ /Switched_Tag_2D_Collision_Detection/diff_sum_result +3V3 -3V3 Net-_D5-A_ LM358/NS
R26 /p1_it_button Net-_C1-Pad2_ 10k
R32 Net-_U11-+_ GND 10k
R31 /It_Player_Determination_/p2_it_value Net-_U11--_ 10k
R30 /It_Player_Determination_/p1_it_value Net-_U11-+_ 10k
R33 Net-_U11--_ /It_Player_Determination_/it_val_diff 10k
XU11 Net-_U11-+_ Net-_U11--_ +3V3 -3V3 /It_Player_Determination_/it_val_diff LM358/NS
C4 /It_Player_Determination_/p2_it_value Net-_U10--_ 1u
R29 Net-_U10--_ /It_Player_Determination_/p2_it_value 10k
R27 /p2_it_button Net-_C2-Pad2_ 10k
C2 Net-_U10--_ Net-_C2-Pad2_ 3.3u
XU10 GND Net-_U10--_ +3V3 -3V3 /It_Player_Determination_/p2_it_value LM358/NS
D6 /It_Player_Determination_/it_val_diff /p2_it_signal D1N914
R34 GND /p2_it_signal 10k
XU9 GND Net-_U9--_ +3V3 -3V3 /It_Player_Determination_/p1_it_value LM358/NS
C1 Net-_U9--_ Net-_C1-Pad2_ 3.3u
C3 /It_Player_Determination_/p1_it_value Net-_U9--_ 1u
R28 Net-_U9--_ /It_Player_Determination_/p1_it_value 10k
R36 /p1_it_signal Net-_U12--_ 10k
D7 Net-_D7-A_ /It_Player_Determination_/it_val_diff D1N914
R35 Net-_U12--_ Net-_D7-A_ 10k
XU12 GND Net-_U12--_ +3V3 -3V3 /p1_it_signal LM358/NS
XQ1 /p1_it_signal /collision_detect_signal /p1_win_signal RUL035N02
R37 /p1_win_signal GND 1k
R38 /p2_win_signal GND 1k
XQ3 /p2_it_signal /p1_it_signal /two_winner_ignore_signal RUL035N02
R39 /two_winner_ignore_signal GND 1k
XQ2 /p2_it_signal /collision_detect_signal /p2_win_signal RUL035N02
.end
